# Keil uVision project _HC32F460.uvprojx, settings and files
target HC32F460 (6140000::V6.14::ARMCLANG)
  device: HC32F460PETB HDSC
  pack: HDSC.HC32F46x.1.0.6
  cpu: IRAM(0x1FFF8000,0x2F000) IRAM2(0x200F0000,0x1000) IROM(0x00000000,0x80000) IROM2(0x03000C00,0x003FC) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WP2345_Main_HC32F460 +hex
  AfterMake: $KARM\ARMCC\bin\HexFileParse_V1.0.5.exe  "$L..\Release\HexFileParseConfig_WP2345.json"
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=5 wLevel=4
  c define: __VTOR_PRESENT=1
  c include: .\common;.\driver;..\UserCode;..\UserCode\04_Thread;..\UserCode\00_ThirdParty\RealTimeTerminal\RTT;..\UserCode\00_ThirdParty\Func_Lib;..\UserCode\02_Drv;..\UserCode\02_Drv\Key;..\UserCode\03_App;..\UserCode\Debug;..\UserCode\Debug\FinSH;..\User\osTask;..\User\app\Adc;..\User\app\Datalog;..\User\app\Program;..\User\app\Ui;..\UserCode\02_Drv\Wifi;..\UserCode\02_Drv\Linkage;..\UserCode\02_Drv\Phone;..\UserCode\02_Drv\Pump;..\UserCode\03_App\SelfClean;..\UserCode\02_Drv\Log;..\UserCode\02_Drv\Parameter;..\UserCode\03_App\WifiPair;..\UserCode\02_Drv\Voice;..\UserCode\03_App\Charge;..\UserCode\03_App\Discharge;..\UserCode\03_App\Idle;..\UserCode\03_App\Demonstrator;..\UserCode\03_App\Tester;..\UserCode\02_Drv\Ota;..\UserCode\03_App\Clean;..\UserCode\02_Drv\Electrolysis;..\UserCode\02_Drv\Fault;..\UserCode\03_App\WifiPair;..\UserCode\02_Drv\CommTester;..\UserCode\00_ThirdParty\Crc8;..\UserCode\03_App\Tester;..\UserCode\03_App\Iap;..\UserCode\02_Drv\Update;..\UserCode\00_ThirdParty\cJSON;..\UserCode\02_Drv\Phone;..\UserCode\01_Bsp_HC32F460\Other;..\UserCode\01_Bsp_HC32F460\TIM;..\UserCode\01_Bsp_HC32F460\UART;..\UserCode\01_Bsp_HC32F460\UART\UART0;..\UserCode\01_Bsp_HC32F460\UART\UART1;..\UserCode\01_Bsp_HC32F460\UART\UART2;..\UserCode\01_Bsp_HC32F460\UART\UART3;..\UserCode\01_Bsp_HC32F460\IIC;..\UserCode\01_Bsp_HC32F460;..\UserCode\02_Drv\Motor;..\UserCode\02_Drv\Sensor;..\UserCode\02_Drv\BT;..\UserCode\02_Drv\Linecross;..\UserCode\02_Drv\Panel;..\UserCode\02_Drv\music;..\UserCode\02_Drv\NFC;..\UserCode\02_Drv\WaterLevel;..\UserCode\02_Drv\NTC;..\UserCode\02_Drv\GD25Q80;..\UserCode\02_Drv\TDS;..\UserCode\02_Drv\WaterFlow;..\UserCode\03_App\BoilPointLearn;..\UserCode\03_App\WarmWater;..\UserCode\03_App\Supply;..\UserCode\03_App\Heat;..\UserCode\03_App\User;..\UserCode\02_Drv\LED
  library: MicroLIB
  memory RVCT4: ROM 0x6000 size 0x80000
  memory RVCT5: ROM 0x3000c00 size 0x3fc
  memory RVCT9: RAM 0x1fff8000 size 0x2f000
  memory RVCT10: RAM 0x200f0000 size 0x1000
  link misc: --keep=*Handler
  group common
    ./common/: main.c ddl_config.h hc32_common.h hc32_ddl.h hc32f46x.h startup_hc32f46x.s system_hc32f46x.c system_hc32f46x.h
    ../UserCode/: Config.h
  group driver
    ./driver/: hc32f46x_adc.c hc32f46x_aes.c hc32f46x_can.c hc32f46x_clk.c hc32f46x_cmp.c hc32f46x_crc.c hc32f46x_dcu.c hc32f46x_dmac.c hc32f46x_efm.c hc32f46x_emb.c hc32f46x_event_port.c hc32f46x_exint_nmi_swi.c hc32f46x_gpio.c hc32f46x_hash.c hc32f46x_i2c.c hc32f46x_i2s.c hc32f46x_icg.c hc32f46x_interrupts.c hc32f46x_keyscan.c hc32f46x_mpu.c hc32f46x_ots.c hc32f46x_pwc.c hc32f46x_qspi.c hc32f46x_rmu.c hc32f46x_rtc.c hc32f46x_sdioc.c hc32f46x_spi.c hc32f46x_sram.c hc32f46x_swdt.c hc32f46x_timer0.c hc32f46x_timer4_cnt.c hc32f46x_timer4_emb.c hc32f46x_timer4_oco.c hc32f46x_timer4_pwm.c hc32f46x_timer4_sevt.c hc32f46x_timer6.c hc32f46x_timera.c hc32f46x_trng.c hc32f46x_usart.c hc32f46x_utility.c hc32f46x_wdt.c
  group 00_ThirdParty
    ../UserCode/00_ThirdParty/RealTimeTerminal/RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
    ../UserCode/00_ThirdParty/Func_Lib/: Func_Array.c Func_Hex.c Func_Null.c Func_String.c
    ../UserCode/00_ThirdParty/Crc8/: Crc8.c
    ../UserCode/00_ThirdParty/cJSON/: cJSON.c
  group 01_Bsp
    ../UserCode/01_Bsp_HC32F460/: Bsp.c
  group 01_Bsp/Other
    ../UserCode/01_Bsp_HC32F460/Other/: EXTI.c IO.c Mcu.c sADC.c sFlash.c WDG.c sSPI.c
  group 01_Bsp/TIM
    ../UserCode/01_Bsp_HC32F460/TIM/: TIM0.c TIMA.c
  group 01_Bsp/IIC
    ../UserCode/01_Bsp_HC32F460/IIC/: IIC.c
  group 02_Drv
    ../UserCode/02_Drv/: Drv.c
  group 02_Drv/UART
    ../UserCode/01_Bsp_HC32F460/UART/UART0/: UART0.c UART0_Rx.c UART0_Tx.c
    ../UserCode/01_Bsp_HC32F460/UART/UART1/: UART1.c UART1_Rx.c UART1_Tx.c
    ../UserCode/01_Bsp_HC32F460/UART/UART2/: UART2.c UART2_Rx.c UART2_Tx.c
    ../UserCode/01_Bsp_HC32F460/UART/UART3/: UART3.c UART3_Rx.c UART3_Tx.c
  group 02_Drv/Key
    ../UserCode/02_Drv/Key/: Key.c
  group 02_Drv/LED
    ../UserCode/02_Drv/LED/: LED.c
  group 02_Drv/Panel
    ../UserCode/02_Drv/Panel/: Panel.c PanelAnalyze.c
  group 02_Drv/Wifi
    ../UserCode/02_Drv/Wifi/: Wifi.c Wifi_String.c WifiRx.c WifiRx_FPm.c WifiRx_FPp.c WifiRx_FPq.c WifiRx_FPqb.c WifiRx_FR.c WifiRx_MMI_Analyize.c WifiTx.c WifiTx_FP.c WifiTx_FPb.c WifiTx_FR.c Ble.c
  group 02_Drv/CommTester
    ../UserCode/02_Drv/CommTester/: CommTester.c CommTester_Rx_Byte.c CommTester_Rx_Frame.c CommTester_Tx.c CommTester_Tx_Frame.c
  group 02_Drv/NFC
    ../UserCode/02_Drv/NFC/: NFC.c FM175XX.c MIFARE.c READER_API.c
  group 02_Drv/Update
    ../UserCode/02_Drv/Update/: Update.c UpdateOta.c UpdateOtaMcu.c
  group 02_Drv/WaterLevel
    ../UserCode/02_Drv/WaterLevel/: WaterLevel.c
  group 02_Drv/TDS
    ../UserCode/02_Drv/TDS/: TDS.c
  group 02_Drv/Linecross
    ../UserCode/02_Drv/Linecross/: Linecross.c
  group 02_Drv/NTC
    ../UserCode/02_Drv/NTC/: NTC.c
  group 02_Drv/WaterFlow
    ../UserCode/02_Drv/WaterFlow/: WaterFlow.c
  group 02_Drv/Pump
    ../UserCode/02_Drv/Pump/: Pump.c
  group 02_Drv/Motor
    ../UserCode/02_Drv/Motor/: Motor.c
  group 02_Drv/GD25Q80
    ../UserCode/02_Drv/GD25Q80/: GD25Q80.c
  group 02_Drv/Fault
    ../UserCode/02_Drv/Fault/: Fault.c
  group 02_Drv/Log
    ../UserCode/02_Drv/Log/: App_Datalog.c Log.c Parameter.c Parameter_MaxModeType.c Parameter_ToolConfig.c Parameter_ToolSn.c Parameter_WifiType.c
  group 03_App
    ../UserCode/03_App/: App.c UserState_Goto.c
    ../UserCode/03_App/SelfClean/: SelfClean.c
    ../UserCode/03_App/WifiPair/: WifiPair.c
    ../UserCode/03_App/BoilPointLearn/: BoilPoint.c
    ../UserCode/03_App/WarmWater/: WarmWater.c
    ../UserCode/03_App/Supply/: SupplyWater.c
    ../UserCode/03_App/Heat/: Heat.c
    ../UserCode/03_App/User/: User.c
  group 04_Thread
    ../UserCode/04_Thread/: UserMain.c Thread_Wifi.c
    ../UserCode/: Config.h
  group Debug
    ../UserCode/Debug/: UserDebug.c Interval.c
    ../UserCode/Debug/FinSH/: FinSH_RealTimeTerminal.c
software components: CMSIS:CORE 5.4.0, RTOS:kernel 3.1.3, RTOS:shell 3.1.3
